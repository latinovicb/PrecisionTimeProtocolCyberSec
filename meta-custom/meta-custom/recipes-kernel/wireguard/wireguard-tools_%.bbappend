DEPENDS_remove = "wireguard-module"
RDEPENDS_${PN}_remove = "wireguard-module"


